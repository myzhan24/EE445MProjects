# Keil uVision project FixedScheduler.uvproj, settings and files
target FixedScheduler (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: FixedScheduler
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c osasm.s ADC.c Interpreter.c os.c SysTickInts.c UART.c heap.c ST7735.c lab2.c PID_stm32.s cr4_fft_64_stm32.s Timer3A.c Switch.c Timer1A.c
