# Keil uVision project FixedScheduler.uvproj, settings and files
target FixedScheduler (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: FixedScheduler
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ADC.c Filter.c heap.c Interpreter.c Lab4.c os.c PLL.c ST7735.c Switch.c SysTickInts.c Timer0A.c Timer1A.c Timer3A.c UART.c cr4_fft_64_stm32.s osasm.s startup.s PWM.c
